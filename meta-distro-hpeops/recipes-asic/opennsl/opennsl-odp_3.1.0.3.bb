require opennsl.inc

LIC_FILES_CHKSUM = "file://packages/cdp/docs/LICENSE_CDP_BIN;md5=e4111c2d8b944da9d44a0c458635d87f"
SRCREV = "7d31d35dbc1040e194d6a676af1e28e33edcc858"
