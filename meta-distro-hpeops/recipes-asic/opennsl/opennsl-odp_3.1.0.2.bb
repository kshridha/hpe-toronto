require opennsl.inc

LIC_FILES_CHKSUM = "file://packages/cdp/docs/LICENSE_CDP_BIN;md5=e4111c2d8b944da9d44a0c458635d87f"
SRCREV = "9056aee5e91f293d3cec7d782c2bf0229201890a"
