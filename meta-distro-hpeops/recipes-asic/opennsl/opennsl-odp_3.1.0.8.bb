require opennsl.inc

LIC_FILES_CHKSUM = "file://packages/cdp/docs/LICENSE_CDP_BIN;md5=e4111c2d8b944da9d44a0c458635d87f"
SRCREV = "bd595969118a534e356a7fd1faef3a74762e578c"
