RDEPENDS_packagegroup-ops-base += " \
    hpe-snmpd \
    hpe-l2macd \
    hpe-mclagd \
"

RDEPENDS_packagegroup-ops-base_remove += " \
    hpe-snmpd \
    hpe-l2macd \
    hpe-mclagd \
    ops-broadview \
"
