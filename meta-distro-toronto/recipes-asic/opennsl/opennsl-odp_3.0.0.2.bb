require opennsl.inc

LIC_FILES_CHKSUM = "file://packages/cdp/docs/LICENSE_CDP_BIN;md5=e4111c2d8b944da9d44a0c458635d87f"
SRCREV = "11383a28bd96eca446f0e7f5994e687d2c0af7be"
