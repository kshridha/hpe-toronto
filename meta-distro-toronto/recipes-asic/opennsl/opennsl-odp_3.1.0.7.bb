require opennsl.inc

LIC_FILES_CHKSUM = "file://packages/cdp/docs/LICENSE_CDP_BIN;md5=e4111c2d8b944da9d44a0c458635d87f"
SRCREV = "1107bc2ac1836c7de149f332a20c5c4c2206a9f5"
