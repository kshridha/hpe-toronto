require opennsl.inc

LIC_FILES_CHKSUM = "file://packages/cdp/docs/LICENSE_CDP_BIN;md5=97cc5e596a4b958d6e1767e75ea007ce"
SRCREV = "76d20cb2a104dc8f3cbf399727e96e2a2d2a7d5e"
